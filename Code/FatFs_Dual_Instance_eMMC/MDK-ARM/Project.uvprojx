# Keil uVision project Project.uvprojx, settings and files
target STM32H747_EVAL_CM4 (6190000::V6.19::ARMCLANG)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_HS
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM4,USE_USB_HS
  c include: ../CM4/Inc;../../Drivers/CMSIS/Include;../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../Drivers/STM32H7xx_HAL_Driver/Inc;../../Drivers/BSP/STM32H747I_EVAL;../../Drivers/BSP/Components/Common;../../Middlewares/Third_Party/FatFs/src;../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;..\Common\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c usbh_conf.c
  group Application/CM7
    ../CM7/Src/: main.c stm32h7xx_it.c main_back.c stm32h7xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32h747xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32H747_EVAL_CM7
    ../../Drivers/BSP/STM32H747I_EVAL/: stm32h747i_eval.c stm32h747i_eval_sd.c stm32h747i_eval_mmc.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c
  group Middlewares/FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Common/Src/: mmc_diskio.c
    ../CM7/Src/: sd_diskio_dma.c
    ../CM4/Src/: usbh_diskio.c
  group Middlewares/FatFs/Options
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/STM32_USBH_LIBRARY/Class
    ../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_LIBRARY/Core
    ../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
target STM32H747_EVAL_CM7 (6190000::V6.19::ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x24000000-0x2407FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7
  c include: ../CM7/Inc;../../Drivers/CMSIS/Include;../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../Drivers/STM32H7xx_HAL_Driver/Inc;../../Drivers/BSP/STM32H747I_EVAL;../../Drivers/BSP/Components/Common;../../Middlewares/Third_Party/FatFs/src;..\Common\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 5.6.0
