# Keil uVision project Project.uvprojx, settings and files
target STM32H747I-EVAL_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IROM(0x08100000-0x81FFFFF) IRAM(0x10000000-0x10047FFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM4,CH7
  c include: ../CM4/Inc;../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../Drivers/STM32H7xx_HAL_Driver/Inc;../../Middlewares/Third_Party/FatFs/src/;../../Drivers/BSP/STM32H747I_EVAL;../Common/Inc;../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../Middlewares/Third_Party/FreeRTOS/Source/include;../../Middlewares/Third_Party/FreeRTOS/Source;../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  group Application/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c
  group Application/CM7
    ../CM7/Src/: keyboard.c main.c menu.c mouse.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c usbh_conf.c
  group Application/MDK-ARM
    ./: startup_stm32h747xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../Drivers/BSP/Components/mipi_lcd_1024x600/: Eugen_MIPI_LCD_1024x600.lib
    ../../Drivers/BSP/Components/mipi_lcd_1280x720/: Eugen_MIPI_LCD_1280x720.lib
  group Drivers/BSP/STM32H747I-EVAL
    ../../Drivers/BSP/STM32H747I_EVAL/: stm32h747i_eval.c stm32h747i_eval_lcd.c stm32h747i_eval_sdram.c stm32h747i_eval_lcd_clock_config.c stm32h747i_eval_lcd_ltdc.c stm32h747i_eval_lcd_mipi_1024x600.c stm32h747i_eval_lcd_mipi_1280x720.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_ll_fmc.c stm32h7xx_ll_usb.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_hcd.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c
  group Middlewares/STM32_USB_Host_Library/Core
    ../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/STM32_USB_Host_Library/Class/HID
    ../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Utilities
    ../../Utilities/Log/: lcd_log.c
target USBD-FS_DSI (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x24000000-0x2407FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Project_FS_DSI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_FS
  c include: ../CM7/Inc;../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../Drivers/STM32H7xx_HAL_Driver/Inc;../../Drivers/BSP/STM32H747I_EVAL;../../Drivers/BSP/Components/mfxstm32l152;../../Drivers/BSP/Components/Common;../../Drivers/BSP/Components;../../Middlewares/Third_Party/FatFs/Src;../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../Utilities/Fonts;../../Utilities/Log;../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../Middlewares/Third_Party/FreeRTOS/Source/include;../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../Drivers/BSP/Components/otm8009a;../../Drivers/BSP/Components/stmpe811
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-FS_DSI_1024x600 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_FS_DSI_1024x600 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_FS,USE_1024x600
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-FS_DSI_1280x720 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_FS_DSI_1280x720 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_FS,USE_1280x720
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS-IN-FS_DSI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS-IN-FS_DSI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS_IN_FS
  c include: ../CM7/Inc;../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../Drivers/STM32H7xx_HAL_Driver/Inc;../../Drivers/BSP/STM32H747I_EVAL;../../Drivers/BSP/Components/mfxstm32l152;../../Drivers/BSP/Components/Common;../../Drivers/BSP/Components;../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc;../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../Utilities/Fonts;../../Utilities/Log;../../Middlewares/Third_Party/FatFs/src;../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../Middlewares/Third_Party/FreeRTOS/Source/include;../../Middlewares/Third_Party/FreeRTOS/Source;../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../Drivers/BSP/Components/stmpe811;../../Drivers/BSP/Components/otm8009a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS-IN-FS_DSI_1024x600 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS-IN-FS_DSI_1024x600 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS_IN_FS,USE_1024x600
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS-IN-FS_DSI_1280x720 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS-IN-FS_DSI_1280x720 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS_IN_FS,USE_1280x720
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS_DSI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS_DSI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS_DSI_1024x600 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS_DSI_1024x600 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS,USE_1024x600
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS_DSI_1280x720 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS_DSI_1024x600 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-FS_LTDC_320x240 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_FS_LTDC_320x240 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_FS,USE_320x240
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-FS_LTDC_480x272 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_FS_LTDC_480x272 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_FS,USE_480x272
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-FS_LTDC_640x480 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_FS_LTDC_640x480 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_FS,USE_640x480
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-FS_LTDC_800x480 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_FS_LTDC_800x480 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_FS,USE_800x480
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-FS_LTDC_800x600 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_FS_LTDC_800x600 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_FS,USE_800x600
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-FS_LTDC_1020x600 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_FS_LTDC_1024x600 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS-IN-FS_LTDC_320x240 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS-IN-FS_LTDC_320x240 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS_IN_FS,USE_320x240
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS-IN-FS_LTDC_480x272 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS-IN-FS_LTDC_480x272 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS_IN_FS,USE_480x272
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS-IN-FS_LTDC_640x480 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS-IN-FS_LTDC_640x480 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS_IN_FS,USE_640x480
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS-IN-FS_LTDC_800x480 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS-IN-FS_LTDC_800x480 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS_IN_FS,USE_800x480
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS-IN-FS_LTDC_800x600 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS-IN-FS_LTDC_800x600 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS_IN_FS,USE_800x600
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS-IN-FS_LTDC_1024x600 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS-IN-FS_LTDC_1024x600 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS_LTDC_320x240 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS_LTDC_320x240 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS,USE_320x240
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS_LTDC_480x272 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS_LTDC_480x272 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS,USE_480x272
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS_LTDC_640x480 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS_LTDC_640x480 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS,USE_640x480
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS_LTDC_800x480 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS_LTDC_800x480 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS,USE_800x480
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS_LTDC_800x600 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS_LTDC_800x600 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,CH7,USE_USB_HS,USE_800x600
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
target USBD-HS_LTDC_1024x600 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: Project_HS_LTDC_1024x600 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 4.3.0
