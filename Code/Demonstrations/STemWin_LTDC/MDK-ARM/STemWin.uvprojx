# Keil uVision project STemWin.uvprojx, settings and files
target STemWin-STM32H747I-EVAL_OoB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IROM_ML(0x08000000-0x803FFFF) IROM_STEW(0x08040000-0x809FFFF) IROM_EWIZ(0x080A0000-0x80FFFFF) IROM_STFW(0x08100000-0x813FFFF) IROM_TGFX(0x08140000-0x81DFFFF) IROM_CUC(0x081E0000-0x81FFFFF) IRAM2(0x00000000-0xFFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x24000000-0x2407FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STemWin-STM32H747I-EVAL_OoB_V1.0.0
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,USE_STM32H747I_EVAL_OOB,CORE_CM7,BSP_USE_CMSIS_OS,DEBUG_HW_JPEG__N,USE_SDCARD,USE_USB_HS
  c include: ../Gui/STemWin_Addons;../Config;../Core/inc;../../../Utilities/CPU;../../../Drivers/CMSIS/Include;../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../Drivers/BSP/STM32H747I_EVAL;../../../Drivers/BSP/Components;../../../Drivers/BSP/STM32H747I_EVAL;../../../Drivers/BSP/Components/Common;../../../Middlewares/ST/STemWin/inc;../../../Middlewares/Third_Party/FatFs/src;../../../Middlewares/Third_Party/FatFs/src/drivers;../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1;../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Modules/Common;../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../Gui/Target;../Gui/Core/video_player;../Modules/audio_player;../Modules/audio_player/Inc;../Modules/audio_player/App;../Modules/audio_player/Addons/Common/Inc;../Modules/audio_player/Addons/SRC236/Inc;../Modules/audio_player/Addons/SRC441/Inc;../Modules/video_player;../Modules/dual_core;../../extra_modules/STIPC/Core/Common/Inc
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: STemWin-STM32H747I-EVAL_OoB\Exe\STemWin-STM32H747I-EVAL_OoB_V1.0.sct
  group Application/MDK-ARM
    ./: startup_stm32h747xx.s
    ./: Media.s
  group Application/User/Core
    ../../extra_modules/STIPC/Core/Common/Src/: cm_ipc.c
    ../Core/Src/: k_bsp.c k_calibration.c k_menu.c k_mfx.c k_module.c k_rtc.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c storage.c system_stm32h7xx.c
    ../Config/: usbh_conf.c
  group Application/User/Gui/analog_clock
    ../Gui/Core/anolog_clock/: analog_clock_win.c
    ../Gui/Core/anolog_clock/generated/: Arial32.c
  group Application/User/Gui/audio_player
    ../Gui/Core/audio_player/: audio_player_win.c visualization.c
  group Application/User/Gui/dual_core
    ../Gui/Core/dual_core/: dual_core_win.c
  group Application/User/Gui/games
    ../Gui/Core/games/: rocket_game_win.c
  group Application/User/Gui/graphic_effect
    ../Gui/Core/graphic_effect/: fatfs_storage.c filtring.c graphic_effects_win.c
  group Application/User/Gui/settings
    ../Gui/Core/settings/: settings_win.c
  group Application/User/Gui/video_player
    ../Gui/Core/video_player/: jpeg_utils.c video_player_win.c
  group Application/User/Modules/audio_player/Addons/SRC236
    ../Modules/audio_player/Addons/SRC236/Lib/: SRC236HQ_CM7_Keil.lib
  group Application/User/Modules/audio_player/Addons/SRC441
    ../Modules/audio_player/Addons/SRC441/Lib/: SRC441HQ_CM7_Keil.lib
  group Application/User/Modules/audio_player/App
    ../Modules/audio_player/App/: audio_player_app.c
  group Application/User/Modules/audio_player/Player
    ../Modules/audio_player/Src/: aviprocess.c coders.c fwkmempool.c player.c songutilities.c wavprocess.c
  group Application/User/Modules/dual_core
    ../Modules/dual_core/: GUI_AVI_2.c video_player_app_2.c
  group Application/User/Modules/video_player
    ../Modules/video_player/: GUI_AVI.c video_player_app.c
  group Application/User/Utilities
    ../../../Utilities/CPU/: cpu_utils.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../Drivers/BSP/Components/ft5426/: ft5426.c
    ../../../Drivers/BSP/Components/tsc2007/: tsc2007.c
  group Drivers/BSP/STemWin-STM32H747I-EVAL
    ../../../Drivers/BSP/STM32H747I_EVAL/: stm32h747i_eval.c stm32h747i_eval_audio.c stm32h747i_eval_qspi.c stm32h747i_eval_sd.c stm32h747i_eval_sdram.c stm32h747i_eval_ts.c stm32h747i_eval_ft5426_ts.c stm32h747i_eval_tsc2007_ts.c
  group Drivers/STM32H7xx_HAL_Drivers
    ../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dma2d.c stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dfsdm.c
  group Middlewares/FatFs/Core
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Config/: sd_diskio.c sd_diskio_dma.c sd_diskio_dma_rtos.c usbh_diskio.c usbh_diskio_dma.c
  group Middlewares/FatFs/Options
    ../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
  group Middlewares/PDM
    ../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_Keil_wc16.lib
  group Middlewares/STemWin/Library
    ../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_OS_wc16_ARGB.a
  group Middlewares/STemWin/OS
    ../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: STemWin_Addons_CM7_wc16.a
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
target STemWin-STM32H747I-EVAL_TSC2007 (6190000::V6.19::ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: STemWin-STM32H747I-EVAL_V1.0.0
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,USE_PWR_LDO_SUPPLY,CORE_CM7,BSP_USE_CMSIS_OS,DEBUG_HW_JPEG__N,USE_SDCARD,USE_USB_HS,USE_800x480
  c include: ../Gui/STemWin_Addons;../Config;../Core/inc;../../../Utilities/CPU;../../../Drivers/CMSIS/Include;../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../Drivers/BSP/STM32H747I_EVAL;../../../Drivers/BSP/Components;../../../Drivers/BSP/STM32H747I_EVAL;../../../Drivers/BSP/Components/Common;../../../Middlewares/ST/STemWin/inc;../../../Middlewares/Third_Party/FatFs/src;../../../Middlewares/Third_Party/FatFs/src/drivers;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM7\r0p1;../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../Middlewares/Third_Party/LwIP/src/include/;../../../Middlewares/Third_Party/LwIP/system;../../../Middlewares/Third_Party/LwIP/system/OS;../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Modules/Common;../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../Gui/Target;../Gui/Core/video_player;../Modules/audio_player;../Modules/audio_player/Inc;../Modules/audio_player/App;../Modules/audio_player/Addons/Common/Inc;../Modules/audio_player/Addons/SRC236/Inc;../Modules/audio_player/Addons/SRC441/Inc;../Modules/video_player;../Modules/dual_core;../../extra_modules/STIPC/Core/Common/Inc
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: STemWin-STM32H747I-EVAL\Exe\STemWin-STM32H747I-EVAL_V1.0.sct
  link misc: --keep *(demo_icon_section)
--keep *(demo_logo_section)
target STemWin-STM32H747I-EVAL_FT5426 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: as above
  output: STemWin-STM32H747I-EVAL_V1.0.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,BSP_USE_CMSIS_OS,DEBUG_HW_JPEG__N,USE_SDCARD,USE_PWR_LDO_SUPPLY,USE_USB_HS,USE_800x480,USE_FT5426
  c include: ../Gui/STemWin_Addons;../Config;../Core/inc;../../../Utilities/CPU;../../../Drivers/CMSIS/Include;../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../Drivers/BSP/STM32H747I_EVAL;../../../Drivers/BSP/Components;../../../Drivers/BSP/STM32H747I_EVAL;../../../Drivers/BSP/Components/Common;../../../Middlewares/ST/STemWin/inc;../../../Middlewares/Third_Party/FatFs/src;../../../Middlewares/Third_Party/FatFs/src/drivers;../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1;../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../Middlewares/Third_Party/LwIP/src/include/;../../../Middlewares/Third_Party/LwIP/system;../../../Middlewares/Third_Party/LwIP/system/OS;../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Modules/Common;../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../Gui/Target;../Gui/Core/video_player;../Modules/audio_player;../Modules/audio_player/Inc;../Modules/audio_player/App;../Modules/audio_player/Addons/Common/Inc;../Modules/audio_player/Addons/SRC236/Inc;../Modules/audio_player/Addons/SRC441/Inc;../Modules/video_player;../Modules/dual_core;../../extra_modules/STIPC/Core/Common/Inc
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: STemWin-STM32H747I-EVAL\Exe\STemWin-STM32H747I-EVAL_V1.0.sct
  link misc: --keep *(demo_icon_section)
--keep *(demo_logo_section)
software components: CMSIS:CORE 5.6.0
