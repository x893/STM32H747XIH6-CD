# Keil uVision project Project.uvprojx, settings and files
target STM32H747I_EVAL_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32H747I_EVAL_CM4
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM4
  c include: ../Common/Inc;../CM4/Inc;../../Drivers/CMSIS/Include;../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../Drivers/STM32H7xx_HAL_Driver/Inc;../../Drivers/BSP/STM32H747I_EVAL;../../Drivers/BSP/Components/Common;../../Utilities/Log;../../Utilities/Fonts;../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../Drivers/BSP/Components/mipi_lcd_1280x720/: Eugen_MIPI_LCD_1280x720.lib
    ../../Drivers/BSP/Components/mipi_lcd_1024x600/: Eugen_MIPI_LCD_1024x600.lib
  group Drivers/BSP/STM32H747I_EVAL
    ../../Drivers/BSP/STM32H747I_EVAL/: stm32h747i_eval.c stm32h747i_eval_lcd.c stm32h747i_eval_sdram.c stm32h747i_eval_lcd_ltdc.c stm32h747i_eval_lcd_mipi_1280x720.c stm32h747i_eval_lcd_mipi_1024x600.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
  group Example/User/CM4
    ../CM4/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Example/User/CM7
    ../CM7/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Example/MDK-ARM
    ./: startup_stm32h747xx.s
target STM32H747I_EVAL_CM7_DSI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H747I_EVAL_CM7
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7
  c include: ../Common/Inc;../CM7/Inc;../../Drivers/CMSIS/Include;../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../Drivers/STM32H7xx_HAL_Driver/Inc;../../Drivers/BSP/STM32H747I_EVAL;../../Drivers/BSP/Components/Common;../../Utilities/Log;../../Utilities/Fonts;../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
target STM32H747I_EVAL_CM7_DSI_1024x600 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: STM32H747I_EVAL_CM7_DSI_1024x600
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
target STM32H747I_EVAL_CM7_DSI_1280x720 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: STM32H747I_EVAL_CM7_DSI_1280x720
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
target STM32H747I_EVAL_CM7_LTDC_800x480 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: STM32H747I_EVAL_CM7_LTDC_800x480
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,USE_800x480
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
target STM32H747I_EVAL_CM7_LTDC_800x600 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: STM32H747I_EVAL_CM7_LTDC_800x600
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,USE_800x600
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
target STM32H747I_EVAL_CM7_LTDC_1024x600 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: as above
  output: STM32H747I_EVAL_CM7_LTDC_1024x600
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM7,USE_1024x600
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 4.3.0
